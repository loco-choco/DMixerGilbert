v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
T {NMOS Intrinsic Parameters Extraction} 40 -530 0 0 0.4 0.4 {}
T {Transit Frequency
} 40 -430 0 0 0.4 0.4 {}
T {Intrinsic Gain} 40 -370 0 0 0.4 0.4 {}
T {Current Density} 40 -320 0 0 0.4 0.4 {}
C {transit-frequency.sym} 170 -390 0 0 {name=x1}
C {title.sym} 180 -40 0 0 {name=l1 author="Ivan Pancheniak"}
C {instrinsic-gain.sym} 170 -330 0 0 {name=x2}
